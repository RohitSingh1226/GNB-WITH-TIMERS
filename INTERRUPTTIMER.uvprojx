# Keil uVision project INTERRUPTTIMER.uvprojx, settings and files
target armbayes (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: INTERRUPTTIMER
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group timer
    ./: main.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Device:Startup 2.6.3
